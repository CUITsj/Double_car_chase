<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Prj\IAR\&#x53eF;&#x63A7;&#x6838;&#x805A;&#x53D8;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


